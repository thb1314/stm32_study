# Keil uVision project 01.uvprojx, settings and files
target FLASH (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 01 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\core
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group core
    ../core/: stm32f10x.h STM32F10x.s system_stm32f10x.c
  group user
    ./: main.c
target SRAM (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: 01 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: VECT_TAB_SRAM
  c include: ..\core
  memory RVCT4: ROM 0x20000000 size 0xb000
  memory RVCT9: RAM 0x2000b000 size 0x5000
